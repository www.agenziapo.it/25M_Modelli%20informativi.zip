Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement [Architecture], Option [IfcExportBaseQuantities: Off], Option [IfcExportElementOnOffAndFrozenLayers: On], Option [IfcExplodeExternalReferences: Off], Option [IfcTesselateBSplineCurvesAndSurfaces: Off], Option [IfcExportSweptSolidAsBRep: Off], Option [IfcExportProfileCenterOfGravity: Off], Option [IfcExportMultiPlyElementsAsAggregated: Off], Option [IfcExportTesselation: 0.000000], Option [IfcCreateUniqueGuidForBlocks: On], Option [IfcCreateUniqueGuidForXrefs: On]
File name: 25_stato_di_progetto_4X3.ifc
Time: 2025-04-23T11:31:16+02:00
Author: Undefined
Organization: Undefined
Written by: IfcOpenShell 0.8.3-alpha250421
Made in: Bonsai 0.8.3-alpha250421-5c4f157
Authorization: Undefined

# IfcBuildingElementProxy (6)
Name | In | String Name | Code 1 | Code 2 | Layer Index
Terreno | Lanca | Description: Created by Civil Site Design
Pietrame 300-1000 kg | Corazzamento imbocco | 25_Canale principale nuova lanca | C.L. | LAR | 1
Pietrame 300-1000 kg | Corazzamento imbocco | 25_Canale principale nuova lanca | C.L. | RAR | 1
Pietrame 300-1000 kg | Corazzamento imbocco | 25_Canale principale nuova lanca | RAR | RBAT | 1
Pietrame 300-1000 kg | Corazzamento imbocco | 25_Canale principale nuova lanca | LAR | LBAT | 1
Pietrame 300-1000 kg | Corazzamento imbocco | asse_dente | C.L. | RD | 1
